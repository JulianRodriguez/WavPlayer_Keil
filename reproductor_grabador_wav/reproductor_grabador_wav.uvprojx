# Keil uVision project reproductor_grabador_wav.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC4088FET208 NXP
  pack: Keil.LPC4000_DFP.2.0.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: reproductor_grabador_wav
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group Source Group 1
    ./: bloque.c menu.c timer1.c glcd.c joystick.c diskio.c ff.c rtc.c sd_lpc4088_mci.c sdram.c soporte_nombres_largos.c main.c font8x16.c
  group ::Board Support
    C:/Keil_v5/ARM/PACK/Keil/LPC4000_DFP/2.0.0/Boards/Embedded Artists/LPC4088-32 Developers Kit/Common/: Audio_UDA1380.c
  group ::CMSIS
    C:/Keil_v5/ARM/PACK/ARM/CMSIS/4.5.0/CMSIS/RTOS/RTX/LIB/ARM/: RTX_CM4.lib
    RTE/CMSIS/: RTX_Conf_CM.c
  group ::CMSIS Driver
    C:/Keil_v5/ARM/PACK/Keil/LPC4000_DFP/2.0.0/RTE_Driver/: I2C_LPC40xx.c I2S_LPC40xx.c
  group ::Device
    RTE/Device/LPC4088FET208/: startup_LPC407x_8x_177x_8x.s system_LPC407x_8x_177x_8x.c RTE_Device.h
    C:/Keil_v5/ARM/PACK/Keil/LPC4000_DFP/2.0.0/RTE_Driver/: GPDMA_LPC40xx.c PIN_LPC40xx.c
software components: CMSIS:CORE 4.3.0, CMSIS:RTOS:Keil RTX 4.80.0, Board Support:Audio 1.0.0, CMSIS Driver:I2C 1.0, CMSIS Driver:SAI 1.0, Device:GPDMA 1.0, Device:PIN 1.0, Device:Startup 1.0.1
